# Keil uVision project LD9900-MT(模块).uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LD9900-MT(模块) +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 LD9900MT.c main.c uart.c
