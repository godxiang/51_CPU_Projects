# Keil uVision project aa.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM cores - see ARM Generic
  output: aa
  c flags: Optim=1
