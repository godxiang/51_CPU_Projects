# Keil uVision project GJ45_U8.uvproj, settings and files
target GJ45_U8 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: GJ45_U8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: GJ45_U8.c
