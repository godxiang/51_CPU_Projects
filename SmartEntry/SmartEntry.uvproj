# Keil uVision project SmartEntry.uvproj, settings and files
target target (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SmartEntry +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group Main
    ./: main.c
  group FingermModule
    ./: LD9900MT.c
  group IdCard
    ./: idcard.c
  group FlashOp
    ./: w25q64.c
  group Uart
    ./: uart.c
  group doc
    ./: readme.txt
