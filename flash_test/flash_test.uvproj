# Keil uVision project flash_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: flash_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c w25q64.c uart.c
  group Header
    ./: w25q64.h STC15W4K32S4.h uart.h
